SUMMARY = "Joins the Wi-Fi network from config.env on boot (wlan0, DHCP via systemd-networkd)"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

inherit features_check
REQUIRED_DISTRO_FEATURES = "systemd wifi"

# wpa_supplicant-nl80211-wlan0.conf holds the Wi-Fi PSK: generated by
# `yocto.sh configure` from config.env into MYLAB_GENERATED_DIR
# (build/conf/mylab/), outside the repo. 30-wlan.network is in files/.
FILESEXTRAPATHS:prepend = "${MYLAB_GENERATED_DIR}:"
SRC_URI = " \
    file://wpa_supplicant-nl80211-wlan0.conf \
    file://30-wlan.network \
"
S = "${UNPACKDIR}"

do_install() {
    # Upstream's wpa_supplicant-nl80211@.service reads exactly this path.
    install -d -m 0755 ${D}${sysconfdir}/wpa_supplicant
    install -m 0600 ${UNPACKDIR}/wpa_supplicant-nl80211-wlan0.conf ${D}${sysconfdir}/wpa_supplicant/

    install -d ${D}${sysconfdir}/systemd/network
    install -m 0644 ${UNPACKDIR}/30-wlan.network ${D}${sysconfdir}/systemd/network/

    # Same as `systemctl enable wpa_supplicant-nl80211@wlan0`: the template's
    # [Install] is WantedBy=sys-subsystem-net-devices-%i.device, so the
    # supplicant starts as soon as the kernel creates wlan0.
    install -d ${D}${sysconfdir}/systemd/system/sys-subsystem-net-devices-wlan0.device.wants
    ln -sf ${systemd_system_unitdir}/wpa_supplicant-nl80211@.service \
        ${D}${sysconfdir}/systemd/system/sys-subsystem-net-devices-wlan0.device.wants/wpa_supplicant-nl80211@wlan0.service
}

FILES:${PN} = "${sysconfdir}/wpa_supplicant ${sysconfdir}/systemd"
RDEPENDS:${PN} = "wpa-supplicant"
